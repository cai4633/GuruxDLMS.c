# Keil uVision project GuruxDLMSSimpleServerExample2.uvprojx, settings and files
target GuruxDLMSSimpleServerExample2 (6160000::V6.16::ARMCLANG)
  device: STM32L433RCTxP STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GuruxDLMSSimpleServerExample2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L433xx DLMS_IGNORE_MALLOC DLMS_IGNORE_CLIENT GX_DLMS_MICROCONTROLLER  DLMS_IGNORE_PLC DLMS_IGNORE_HIGH_SHA256 DLMS_IGNORE_HIGH_SHA1 DLMS_IGNORE_HIGH_MD5 DLMS_IGNORE_EXTENDED_REGISTER DLMS_IGNORE_DEMAND_REGISTER DLMS_IGNORE_REGISTER_ACTIVATION DLMS_IGNORE_SCHEDULE DLMS_IGNORE_SPECIAL_DAYS_TABLE DLMS_IGNORE_ASSOCIATION_SHORT_NAME DLMS_IGNORE_IMAGE_TRANSFER DLMS_IGNORE_IEC_LOCAL_PORT_SETUP DLMS_IGNORE_ACTIVITY_CALENDAR DLMS_IGNORE_REGISTER_MONITOR DLMS_IGNORE_IEC_TWISTED_PAIR_SETUP DLMS_IGNORE_MBUS_SLAVE_PORT_SETUP DLMS_IGNORE_UTILITY_TABLES DLMS_IGNORE_MODEM_CONFIGURATION DLMS_IGNORE_AUTO_ANSWER DLMS_IGNORE_AUTO_CONNECT DLMS_IGNORE_TCP_UDP_SETUP DLMS_IGNORE_IP4_SETUP DLMS_IGNORE_IP6_SETUP DLMS_IGNORE_MAC_ADDRESS_SETUP DLMS_IGNORE_PPP_SETUP DLMS_IGNORE_GPRS_SETUP DLMS_IGNORE_SMTP_SETUP DLMS_IGNORE_GSM_DIAGNOSTIC DLMS_IGNORE_REGISTER_TABLE DLMS_IGNORE_STATUS_MAPPING DLMS_IGNORE_MBUS_CLIENT DLMS_IGNORE_PARAMETER_MONITOR DLMS_IGNORE_WIRELESS_MODE_Q_CHANNEL DLMS_IGNORE_MBUS_MASTER_PORT_SETUP DLMS_IGNORE_ZIG_BEE_SAS_STARTUP DLMS_IGNORE_ZIG_BEE_SAS_JOIN DLMS_IGNORE_ZIG_BEE_SAS_APS_FRAGMENTATION DLMS_IGNORE_ZIG_BEE_NETWORK_CONTROL DLMS_IGNORE_DATA_PROTECTION DLMS_IGNORE_ACCOUNT DLMS_IGNORE_CREDIT DLMS_IGNORE_CHARGE DLMS_IGNORE_TOKEN_GATEWAY DLMS_IGNORE_COMPACT_DATA DLMS_IGNORE_LLC_SSCS_SETUP DLMS_IGNORE_PRIME_NB_OFDM_PLC_PHYSICAL_LAYER_COUNTERS DLMS_IGNORE_PRIME_NB_OFDM_PLC_MAC_SETUP DLMS_IGNORE_PRIME_NB_OFDM_PLC_MAC_FUNCTIONAL_PARAMETERS DLMS_IGNORE_PRIME_NB_OFDM_PLC_MAC_COUNTERS DLMS_IGNORE_PRIME_NB_OFDM_PLC_MAC_NETWORK_ADMINISTRATION_DATA DLMS_IGNORE_PRIME_NB_OFDM_PLC_APPLICATIONS_IDENTIFICATION DLMS_IGNORE_ARBITRATOR DLMS_IGNORE_G3_PLC_MAC_LAYER_COUNTERS DLMS_IGNORE_G3_PLC_MAC_SETUP DLMS_IGNORE_G3_PLC_6LO_WPAN DLMS_IGNORE_ARRAY_MANAGER  DLMS_USE_EPOCH_TIME
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l433xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group dlms/include
    ../dlms/include/: apdu.h bitarray.h bytebuffer.h ciphering.h cipheringenums.h client.h converters.h cosem.h crc.h datainfo.h date.h dlms.h dlmssettings.h enums.h errorcodes.h gxaes.h gxarray.h gxdefine.h gxget.h gxignore.h gxint.h gxinvoke.h gxkey.h gxmd5.h gxmem.h gxobjects.h gxserializer.h gxset.h gxsetignoremalloc.h gxsetmalloc.h gxsha1.h gxsha256.h gxvalueeventargs.h helpers.h lnparameters.h message.h notify.h objectarray.h parameters.h replydata.h server.h serverevents.h snparameters.h variant.h
  group dlms/src
    ../dlms/src/: apdu.c bitarray.c bytebuffer.c ciphering.c client.c converters.c cosem.c datainfo.c date.c dlms.c dlmsSettings.c gxaes.c gxarray.c gxget.c gxinvoke.c gxkey.c gxmd5.c gxobjects.c gxserializer.c gxset.c gxsetignoremalloc.c gxsetmalloc.c gxsha1.c gxsha256.c gxvalueeventargs.c helpers.c message.c notify.c objectarray.c parameters.c replydata.c server.c serverevents.c variant.c
software components: CMSIS:CORE 5.6.0
